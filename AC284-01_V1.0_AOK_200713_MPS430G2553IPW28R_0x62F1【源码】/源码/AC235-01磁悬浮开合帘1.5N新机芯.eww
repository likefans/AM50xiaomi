<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\AM65-68-95-TI&#x65B9;&#x6848;&#x5F00;&#x5408;&#x5e18;1.5N&#x65B0;&#x673A;&#x82AF;.ewp</path>
  </project>
  <batchBuild/>
</workspace>


